File: Drive Board/Temperature Measurement.kicad_sch (KiCad schematic)
At the start: 24 parts, among them U2 CD4051B

Commit message: finished RV1 of board
Connections:
- net +3.3V renamed +3V3
